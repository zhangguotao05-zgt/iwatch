# Keil uVision project project.uvprojx, settings and files
target iwatch (ARM-ADS)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: main
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: SIFLI_VERSION=33882113, HAL_USE_NAND, HAL_TICK_PER_SECOND=1000, MEMCPY_NON_DMA, SOC_BF0_HCPU, USE_HAL_DRIVER, BPS_V33_HAL, RT_USING_ARM_LIBC, __FILE__=__FILE_NAME__, LCPU_CONFIG_V1, SIFLI_BUILD="421126d9", ARM_MATH_LOOPUNROLL, SF32LB58X, USE_FULL_ASSERT, PSRAM_CACHE_WB, LV_CONF_KCONFIG_EXTERNAL_INCLUDE=<lv_conf_sifli.h>
  c misc: -Wno-builtin-macro-redefined -march=armv8-m.main+cdecp1
  c include: build_iwatch_sf32lb58_a128_qspi_hcpu;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\boards\common;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\boards\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\boards\include\config\sf32lb58x;..\..\boards\iwatch_sf32lb58_a128_qspi;..\..\boards\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\boards\sf32lb58-lcd_base;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\boards\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\peripherals\common;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\peripherals\display\co5300;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\peripherals\pa\common;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\peripherals\pa\AW8155;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\peripherals\touch_panel\common;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\customer\peripherals\touch_panel\ft6146;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\bsp\sifli\drivers;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\drivers\cmsis\sf32lb58x;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\drivers\cmsis\Include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\CMSIS\Include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\drivers\Include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\drivers\hal_epic_ex;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\FlashDB\inc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\FlashDB\port\fal\inc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\liblc3\src;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\liblc3\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\lvgl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\env_support\cmsis-pack;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\env_support\rt-thread;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\env_support\rt-thread\squareline\ui\lvgl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\libs\nema_gfx\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\core;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\display;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\font;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\indev;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\layouts;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\misc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\osal;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\stdlib;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\themes;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\tick;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\convert;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\dma2d;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\eve;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\nema_gfx;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\opengles;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\sdl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\sw;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\vg_lite;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\convert\helium;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\convert\neon;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\espressif\ppa;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\nxp\g2d;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\nxp\pxp;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\renesas\dave2d;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\sw\arm2d;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\sw\blend;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\sw\blend\arm2d;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\sw\blend\helium;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\draw\sw\blend\neon;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\evdev;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\libinput;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\nuttx;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\opengles;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\qnx;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\sdl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\uefi;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\wayland;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\windows;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\x11;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\drm;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\fb;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\ft81x;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\ili9341;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\lcd;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\lovyan_gfx;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\nv3007;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\nxp_elcdif;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\renesas_glcdc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\st7735;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\st7789;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\st7796;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\st_ltdc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\display\tft_espi;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\draw\eve;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\opengles\assets;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\opengles\opengl_shader;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\opengles\glad\include\EGL;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\opengles\glad\include\glad;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\drivers\opengles\glad\include\KHR;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\layouts\flex;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\layouts\grid;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\barcode;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\bin_decoder;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\bmp;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\expat;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\ffmpeg;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\freetype;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\fsdrv;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\FT800-FT813;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gif;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gstreamer;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\libjpeg_turbo;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\libpng;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\lodepng;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\lz4;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\qrcode;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\rle;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\rlottie;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\svg;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\thorvg;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\tiny_ttf;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\tjpgd;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\frogfs\src;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\frogfs\include\frogfs;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gif\AnimatedGIF\src;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gltf\fastgltf;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gltf\gltf_data;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gltf\gltf_view;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gltf\math;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gltf\stb_image;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gltf\gltf_view\assets;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\gltf\gltf_view\ibl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\thorvg\rapidjson;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\thorvg\rapidjson\error;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\thorvg\rapidjson\internal;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\inc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\lv_vg_lite_hal;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\VGLite;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\VGLiteKernel;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\VGLite\Series\gc255\0x40A;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1215;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1216;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423_ECO;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\misc\cache;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\misc\cache\class;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\misc\cache\instance;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\file_explorer;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\font_manager;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\fragment;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\gridnav;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\ime;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\imgfont;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\monkey;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\observer;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\snapshot;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\sysmon;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\test;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\translation;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\vg_lite_tvg;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\xml;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\others\xml\parsers;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\stdlib\builtin;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\themes\default;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\themes\mono;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\themes\simple;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\3dtexture;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\animimage;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\arc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\arclabel;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\bar;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\button;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\buttonmatrix;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\calendar;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\canvas;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\chart;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\checkbox;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\dropdown;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\image;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\imagebutton;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\keyboard;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\label;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\led;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\line;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\list;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\lottie;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\menu;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\msgbox;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\objx_templ;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\property;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\roller;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\scale;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\slider;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\span;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\spinbox;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\spinner;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\switch;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\table;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\tabview;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\textarea;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\tileview;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\external\lvgl_v9\src\widgets\win;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\button;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\cpu_usage_profiler;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\ezipa_dec;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\sifli_matrix;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\app_fwk;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\app_fwk\reg_fwk;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\app_fwk\dyn_fwk;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\barcode128;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\cell_transform;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl\lv_ext_resouce;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl\lvsf_v9;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl\lvsf_font_v9;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl\lv_drivers_v9;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl\lv_drivers_v9\sifli;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl\lvgl_extensions;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\lvgl\gif_dec;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\sifli_lib\lib;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\middleware\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\os_adaptor\src;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\os_adaptor\inc;..\src\core;..\src\gui_core;..\src\platform;build_iwatch_sf32lb58_a128_qspi_hcpu\src\resource\strings;build_iwatch_sf32lb58_a128_qspi_hcpu\src\gui_apps;..\src\gui_apps\clock;..\src\app_utils;..\src;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\libcpu\arm\cortex-m33;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\libcpu\arm\common;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\cplusplus;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\dfs\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\dfs\filesystems\devfs;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\dfs\filesystems\elmfat;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\dfs\filesystems\dhara\dhara;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\audio;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\spi;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\drivers\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\finsh;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\libc\compilers\armlibc;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\libc\compilers\common\include;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\utilities\llt_mem;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\utilities\ulog;C:\OpenSiFli\SiFli-SDK-v2.5.1-iwatch-locked\rtos\rtthread\components\utilities\ulog\backend
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: build_iwatch_sf32lb58_a128_qspi_hcpu/link.sct
  link misc: --cpu=cortex-m33 --strict --scatter build_iwatch_sf32lb58_a128_qspi_hcpu/link.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers --any_contingency  --list build_iwatch_sf32lb58_a128_qspi_hcpu/main.map  --libpath=D:\keil\MDK5.36/ARM/ARMCLANG/lib --diag_suppress=L6314 --diag_suppress=L6329 --predefine="-DSF32LB58X" --predefine="-DSIFLI_VERSION=33882113" --predefine="-DHAL_USE_NAND" --predefine="-DHAL_TICK_PER_SECOND=1000" --predefine="-DMEMCPY_NON_DMA" --predefine="-DSOC_BF0_HCPU" --predefine="-DUSE_HAL_DRIVER" --predefine="-DBPS_V33_HAL" --predefine="-DLCPU_CONFIG_V1" --predefine="-DSIFLI_BUILD="421126d9"" --predefine="-DARM_MATH_LOOPUNROLL" --predefine="-DSF32LB58X" --predefine="-DUSE_FULL_ASSERT" --predefine="-DPSRAM_CACHE_WB" --predefine="-DLV_CONF_KCONFIG_EXTERNAL_INCLUDE=<lv_conf_sifli.h>" --predefine="-DRT_USING_ARM_LIBC"
  group Kernel
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c memheap2.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/customer/boards/common/: bsp_common.c bsp_psram.c flash.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/customer/boards/sf32lb58-lcd_base/: bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/customer/peripherals/display/co5300/: co5300.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/customer/peripherals/pa/AW8155/: sifli_aw8155.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/customer/peripherals/touch_panel/ft6146/: ft6146.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/bsp/sifli/drivers/: drv_dma.c drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm_tim.c drv_pwm_lptim.c drv_pwm.c drv_spi.c drv_soft_i2c.c drv_i2c.c drv_spi_flash.c drv_spi_nand.c drv_sys_cfg.c drv_rtc.c drv_ext_dma.c drv_audprc.c drv_audcodec.c drv_lcd_private.c drv_lcd.c drv_ram_lcd.c drv_lcd_test.c drv_lcd_fb.c drv_epic.c drv_epic_single.c drv_psram.c drv_mpi.c drv_aes.c drv_encoder.c drv_common.c drv_dbg.c drv_epictl.c
  group CMSIS_BF0
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/drivers/cmsis/sf32lb58x/: bf0_pin_const.c pmu_ldo_update.c lcpu_config_type.c lcpu_patch.c bf0_lcpu_init.c bt_rf_cw_config.c bt_power_config.c bt_afh_test.c bt_rf_fulcal.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/drivers/cmsis/sf32lb58x/Templates/: system_bf0_ap.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/drivers/cmsis/sf32lb58x/Templates/arm/: startup_bf0_hcpu.S
  group BF0_HAL
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/drivers/hal/: bf0_hal.c bf0_hal_adc.c bf0_hal_aes.c bf0_hal_aes_ns.c bf0_hal_audcodec.c bf0_hal_audprc.c bf0_hal_bleaon.c bf0_hal_busmon.c bf0_hal_can.c bf0_hal_cortex.c bf0_hal_crc.c bf0_hal_dcmi.c bf0_hal_dma.c bf0_hal_dsi.c bf0_hal_efuse.c bf0_hal_epic.c bf0_hal_epictl.c bf0_hal_ext_dma.c bf0_hal_ezip.c bf0_hal_facc.c bf0_hal_fft.c bf0_hal_gpio.c bf0_hal_hcd.c bf0_hal_hlp.c bf0_hal_hpaon.c bf0_hal_i2c.c bf0_hal_i2s.c bf0_hal_jpegd.c bf0_hal_lcdc.c bf0_hal_lcdc_aux.c bf0_hal_lcpu_config.c bf0_hal_lpaon.c bf0_hal_lpcomp.c bf0_hal_lptim.c bf0_hal_lrc_cal.c bf0_hal_mailbox.c bf0_hal_mpi.c bf0_hal_mpi_ex.c bf0_hal_mpi_psram.c bf0_hal_nn_acc.c bf0_hal_patch.c bf0_hal_pcd.c bf0_hal_pdm.c bf0_hal_pinmux.c bf0_hal_pmu.c bf0_hal_psram.c bf0_hal_ptc.c bf0_hal_pwm.c bf0_hal_rcc.c bf0_hal_rng.c bf0_hal_rtc.c bf0_hal_sd_ex.c bf0_hal_sdadc.c bf0_hal_sdhci.c bf0_hal_sdmmc.c bf0_hal_secu.c bf0_hal_spi.c bf0_hal_tim.c bf0_hal_tim_ex.c bf0_hal_tsen.c bf0_hal_uart.c bf0_hal_wdt.c bf0_sys_cfg.c flash_table.c nand_table.c sifli_bbm.c
  group lib_hal_epic_ex
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/drivers/hal_epic_ex/: hal_epic_ex_rvds.lib
  group FlashDB
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/FlashDB/port/fal/src/: fal.c fal_flash.c fal_flash_sifli_port.c fal_partition.c fal_rtt.c
  group google_lc3
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/liblc3/src/: attdet.c bits.c bwdet.c energy.c lc3.c ltpf.c mdct.c plc.c sns.c spec.c tables.c tns.c
  group LVGL
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/: lv_init.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/env_support/pikascript/: pika_lv_point_t.c pika_lv_timer_t.c pika_lv_wegit.c pika_lvgl.c pika_lvgl_indev_t.c pika_lvgl_lv_event.c pika_lvgl_lv_obj.c pika_lvgl_lv_style_t.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/env_support/rt-thread/: lv_rt_thread_port.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/env_support/rt-thread/squareline/: lv_ui_entry.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/display/: lv_display.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/layouts/: lv_layout.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/stdlib/: lv_mem.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/themes/: lv_theme.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/tick/: lv_tick.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/convert/: lv_draw_buf_convert.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/opengles/: lv_draw_opengles.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/sdl/: lv_draw_sdl.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/evdev/: lv_evdev.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/qnx/: lv_qnx.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/fb/: lv_linux_fbdev.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/ft81x/: lv_ft81x.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/ili9341/: lv_ili9341.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/lovyan_gfx/: lv_lovyan_gfx.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/nv3007/: lv_nv3007.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/st7735/: lv_st7735.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/st7789/: lv_st7789.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/st7796/: lv_st7796.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/display/tft_espi/: lv_tft_espi.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/draw/eve/: lv_draw_eve_display.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/opengles/assets/: lv_opengles_shader.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/drivers/opengles/glad/src/: egl.c gles2.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/layouts/flex/: lv_flex.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/layouts/grid/: lv_grid.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/barcode/: code128.c lv_barcode.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/bin_decoder/: lv_bin_decoder.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/bmp/: lv_bmp.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/ffmpeg/: lv_ffmpeg.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gif/: lv_gif.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gstreamer/: lv_gstreamer.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/libpng/: lv_libpng.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/lodepng/: lodepng.c lv_lodepng.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/lz4/: lz4.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/rle/: lv_rle.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/rlottie/: lv_rlottie.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/thorvg/: tvgAccessor.cpp tvgAnimation.cpp tvgCanvas.cpp tvgCapi.cpp tvgCompressor.cpp tvgFill.cpp tvgGlCanvas.cpp tvgInitializer.cpp tvgLoader.cpp tvgLottieAnimation.cpp tvgLottieBuilder.cpp tvgLottieExpressions.cpp tvgLottieInterpolator.cpp tvgLottieLoader.cpp tvgLottieModel.cpp tvgLottieModifier.cpp tvgLottieParser.cpp tvgLottieParserHandler.cpp tvgMath.cpp tvgPaint.cpp tvgPicture.cpp tvgRawLoader.cpp tvgRender.cpp tvgSaver.cpp tvgScene.cpp tvgShape.cpp tvgStr.cpp tvgSvgCssStyle.cpp tvgSvgLoader.cpp tvgSvgPath.cpp tvgSvgSceneBuilder.cpp tvgSvgUtil.cpp tvgSwCanvas.cpp tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwPostEffect.cpp tvgSwRaster.cpp tvgSwRenderer.cpp tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgText.cpp tvgWgCanvas.cpp tvgXmlParser.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/tiny_ttf/: lv_tiny_ttf.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gif/AnimatedGIF/src/: gif.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gltf/gltf_data/: lv_gltf_bind.cpp lv_gltf_data.cpp lv_gltf_data_animations.cpp lv_gltf_data_cache.cpp lv_gltf_data_injest.cpp lv_gltf_data_mesh.cpp lv_gltf_data_node.cpp lv_gltf_data_primitive.cpp lv_gltf_data_shader.cpp lv_gltf_data_skin.cpp lv_gltf_data_texture.cpp lv_gltf_uniform_locations.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gltf/gltf_view/: lv_gltf_view.cpp lv_gltf_view_render.cpp lv_gltf_view_shader.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gltf/math/: lv_gltf_math.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/misc/cache/: lv_cache.c lv_cache_entry.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/file_explorer/: lv_file_explorer.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/gridnav/: lv_gridnav.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/ime/: lv_ime_pinyin.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/imgfont/: lv_imgfont.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/monkey/: lv_monkey.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/observer/: lv_observer.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/snapshot/: lv_snapshot.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/sysmon/: lv_sysmon.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/translation/: lv_translation.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/vg_lite_tvg/: vg_lite_matrix.c vg_lite_tvg.cpp
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/stdlib/micropython/: lv_mem_core_micropython.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/stdlib/uefi/: lv_mem_core_uefi.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/themes/default/: lv_theme_default.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/themes/mono/: lv_theme_mono.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/themes/simple/: lv_theme_simple.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/3dtexture/: lv_3dtexture.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/animimage/: lv_animimage.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/arc/: lv_arc.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/arclabel/: lv_arclabel.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/bar/: lv_bar.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/button/: lv_button.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/canvas/: lv_canvas.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/chart/: lv_chart.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/checkbox/: lv_checkbox.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/dropdown/: lv_dropdown.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/image/: lv_image.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/imagebutton/: lv_imagebutton.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/keyboard/: lv_keyboard.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/label/: lv_label.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/led/: lv_led.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/line/: lv_line.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/list/: lv_list.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/lottie/: lv_lottie.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/menu/: lv_menu.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/msgbox/: lv_msgbox.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/objx_templ/: lv_objx_templ.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/roller/: lv_roller.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/scale/: lv_scale.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/slider/: lv_slider.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/span/: lv_span.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/spinbox/: lv_spinbox.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/spinner/: lv_spinner.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/switch/: lv_switch.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/table/: lv_table.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/tabview/: lv_tabview.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/textarea/: lv_textarea.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/tileview/: lv_tileview.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/external/lvgl_v9/src/widgets/win/: lv_win.c
  group middleware
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/button/: button.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/cpu_usage_profiler/: cpu_usage_profiler.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/ezipa_dec/: ezipa_dec.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/sifli_matrix/: sifli_matrix.c
  group app_fwk
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/app_fwk/: app_schedule.c app_schedule_port.c gui_app_fwk.c gui_app_test.c gui_dl_app_fwk.c intent.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/app_fwk/reg_fwk/: app_reg.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/app_fwk/lvgl_v9/: gui_app_trans_anim.c
  group lib_barcode128
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/barcode128/: barcode128_rvds.lib
  group lib_cell_transform
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/cell_transform/: cell_transform_rvds.lib
  group lvgl_sifli
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/lvgl/: littlevgl2rtt.c lvsf_perf.c lvsf_perf_v9.c app_mem.c hash_cache.c
  group lv_ext_resouce
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/lvgl/lv_ext_resouce/: app_comm.c app_lang.c app_nvm_lang_compat.c lv_ext_resource_manager.c lv_ext_resource_manager_builtin.c lv_ext_resource_manager_dl_impl.c service_comm.c
  group LV_SF
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/lvgl/lvsf_v9/: lv_ex_data.c lv_seqimg.c lvsf_ezipa.c lvsf_input.c lvsf_switchanim.c lvsf_switchanim_com.c
  group lvsf_font
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/lvgl/lvsf_font_v9/: lv_font_ubuntu.c
  group lv_drivers
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/lvgl/lv_drivers_v9/sifli/: lv_draw_epic.c lv_draw_epic_arc.c lv_draw_epic_border.c lv_draw_epic_fill.c lv_draw_epic_img.c lv_draw_epic_label.c lv_epic_utils.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/lvgl/lv_drivers_v9/: lv_lcd.c lv_gpu.c lv_keypad.c lv_touch.c lvgl_drv.c lvsf_img_decoder.c lvsf_jpeg_decoder.c
  group lib_gif_dec
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/lvgl/gif_dec/: gif_dec_v9_rvds.lib
  group sifli_lib
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/sifli_lib/lib/: agif.c dummy.c
  group m_system
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/middleware/system/: bf0_common.c
  group os_adapter
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/os_adaptor/src/: os_adaptor_rtthread.c
  group Iwatch_core
    ../src/core/: iw_gui_wait.c iw_input_queue.c
  group Iwatch_gui_core
    ../src/gui_core/: iw_recovery.c
  group Iwatch_platform
    ../src/platform/: iw_drv_touch.c iw_gui_port.c
  group resource
    build_iwatch_sf32lb58_a128_qspi_hcpu/src/resource/images/common/no_ezip/: baro_arrow.tmp.c clock_dial_point_h.tmp.c clock_dial_point_m.tmp.c clock_dial_point_s.tmp.c clock_mickey_hand_hour.tmp.c clock_mickey_hand_minute.tmp.c clock_rotate_bg_bg.tmp.c clock_rotate_bg_bg_small.tmp.c clock_rotate_bg_bg_tiny.tmp.c clock_rotate_bg_hour_hand.tmp.c clock_rotate_bg_minute_hand.tmp.c clock_simple_hour_hand.tmp.c clock_simple_minute_hand.tmp.c clock_simple_second_hand.tmp.c compass_arrow.tmp.c d3d_rotate.tmp.c fashion_hr.tmp.c fashion_min.tmp.c fashion_sec.tmp.c hour_hand2.tmp.c kaleidoscope.tmp.c minute_hand2.tmp.c second_hand2.tmp.c
    build_iwatch_sf32lb58_a128_qspi_hcpu/src/resource/images/common/ezip/: airplane.tmp.c bluetooth.tmp.c clock_40.tmp.c clock_80.tmp.c clock_mickey_eyes01.tmp.c clock_mickey_eyes02.tmp.c clock_mickey_eyes03.tmp.c clock_mickey_shoe01.tmp.c clock_mickey_shoe02.tmp.c clock_mickey_shoe03.tmp.c clock_mickey_shoe04.tmp.c clock_mickey_shoe05.tmp.c compass_arrow_shadow.tmp.c dn.tmp.c down_arrow.tmp.c eco.tmp.c gra_corner_clock1.tmp.c gra_corner_clock2.tmp.c house.tmp.c human1.tmp.c human2.tmp.c img_activity.tmp.c img_alarm.tmp.c img_alarm_2.tmp.c img_calendar.tmp.c img_camera.tmp.c img_clock.tmp.c img_compass.tmp.c img_ecg.tmp.c img_group.tmp.c img_itunes.tmp.c img_left_arrow.tmp.c img_mail.tmp.c img_maps.tmp.c img_messages.tmp.c img_mountion.tmp.c img_passbook.tmp.c img_phone.tmp.c img_photos.tmp.c img_red_heart.tmp.c img_remote.tmp.c img_settings.tmp.c img_stocks.tmp.c img_stopwatch.tmp.c img_workout.tmp.c img_world_clock.tmp.c ms_earth.tmp.c ms_water.tmp.c up_arrow.tmp.c weather.tmp.c wt_circle.tmp.c wt_clock.tmp.c wt_cloudy.tmp.c wt_compass.tmp.c wt_earth.tmp.c wt_rain.tmp.c wt_snow.tmp.c wt_sunny.tmp.c wt_weather.tmp.c wt_wind.tmp.c
    build_iwatch_sf32lb58_a128_qspi_hcpu/src/resource/images/common/large_ezip/: barometer.tmp.c clock_dashes.tmp.c clock_digital_bg.tmp.c clock_mickey_bg.tmp.c clock_mickey_body.tmp.c clock_mickey_head.tmp.c clock_simple_bg.tmp.c compass_bg.tmp.c digital_b_time_0.tmp.c digital_b_time_1.tmp.c digital_b_time_2.tmp.c digital_b_time_3.tmp.c digital_b_time_4.tmp.c digital_b_time_5.tmp.c digital_b_time_6.tmp.c digital_b_time_7.tmp.c digital_b_time_8.tmp.c digital_b_time_9.tmp.c elevation.tmp.c hr_region.tmp.c img_dial_bg.tmp.c
    build_iwatch_sf32lb58_a128_qspi_hcpu/src/resource/images/common/jpeg/: clock_simple_bg_jpeg.tmp.c
    build_iwatch_sf32lb58_a128_qspi_hcpu/src/resource/fonts/: DroidSansFallback.c
    build_iwatch_sf32lb58_a128_qspi_hcpu/src/resource/strings/: en_us.c zh_cn.c lang_pack.c
  group App_watch_demo
    ../src/gui_apps/: watch_demo.c
    ../src/gui_apps/clock/: app_clock_dial.c app_clock_main.c app_clock_rotate_bg.c app_clock_simple.c app_clock_status_bar.c
    ../src/gui_apps/main/: app_mainmenu.c
    ../src/gui_apps/rotation3d/: rotation3d.c
  group App_utils
    ../src/app_utils/: main.c
  group CORTEX-M33
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/libcpu/arm/cortex-m33/: cpuport.c context_rvds.S
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group CPlusPlus
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/cplusplus/: cxx_crt.cpp cxx_mutex.cpp cxx_semaphore.cpp cxx_thread.cpp cxx_crt_init.c
  group Filesystem
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/dfs/filesystems/devfs/: devfs.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group dhara
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/dfs/filesystems/dhara/dhara/: error.c journal.c map.c nand.c
  group DeviceDrivers
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/audio/: audio.c audio_pipe.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/hwmailbox/: hwmailbox.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/hwtimer/: hwtimer.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/misc/: pin.c rt_drv_pwm.c rt_drv_encoder.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/mtd/: mtd_nand.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/rtc/: rtc.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/serial/: serial.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/spi/: spi_core.c spi_dev.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c ringbuffer32.c waitqueue.c workqueue.c
  group finsh
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/libc/compilers/common/: gmtime_r.c unistd.c
  group Utilities
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/utilities/llt_mem/: llt_mem.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/utilities/ulog/: ulog.c
    C:/OpenSiFli/SiFli-SDK-v2.5.1-iwatch-locked/rtos/rtthread/components/utilities/ulog/backend/: console_be.c
